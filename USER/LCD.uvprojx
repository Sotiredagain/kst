# Keil uVision project LCD.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\Timer;..\HARDWARE\RTC;..\HARDWARE\CST816;..\HARDWARE\i2c;..\HARDWARE\MPU6050;..\Middleware\LVGL\GUI;..\Middleware\LVGL\GUI\lvgl;..\Middleware\LVGL\GUI\lvgl\src;..\Middleware\LVGL\GUI\lvgl\examples\porting;..\image;..\SYSTEM\dma;..\APP;..\HARDWARE\HeartRate-02;..\FreeRtos_Include;..\FreeRtos_Portable;..\FreeRtos_Source;..\HARDWARE\ESP8266
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group HARDWARE
    ../HARDWARE/Timer/: Timer.c
    ../HARDWARE/RTC/: RTC.c
    ../HARDWARE/i2c/: bsp_i2c_gpio.c
    ../HARDWARE/LCD/: lcd.c lcd_init.c
    ../HARDWARE/CST816/: CST816.c
    ../HARDWARE/HeartRate-02/: max30102.c
    ../HARDWARE/MPU6050/: mpu6050.c step.c
    ../HARDWARE/ESP8266/: esp8266.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/dma/: dma.c
  group Middlewares/lvgl/src/example/porting
    ../Middleware/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group Middlewares/lvgl/src/core
    ../Middleware/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/lvgl/src/draw
    ../Middleware/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middleware/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Middlewares/lvgl/src/extra
    ../Middleware/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/msg/: lv_msg.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middleware/LVGL/GUI/lvgl/src/extra/: lv_extra.c
  group Middlewares/lvgl/src/font
    ../Middleware/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/lvgl/src/gpu
    ../Middleware/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middleware/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group Middlewares/lvgl/src/hal
    ../Middleware/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/lvgl/src/misc
    ../Middleware/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/lvgl/src/widgets
    ../Middleware/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group APP
    ../APP/: lvgl_app.c
  group FreeRtos_Portable
    ../FreeRtos_Portable/: heap_4.c port.c
  group FreeRtos_Source
    ../FreeRtos_Source/: list.c queue.c tasks.c
